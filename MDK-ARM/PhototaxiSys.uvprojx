# Keil uVision project PhototaxiSys.uvprojx, settings and files
target PhototaxiSys (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: PhototaxiSys +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../SYSTEM/sys;../SYSTEM/delay;../SOFTWARE/JSON;../SOFTWARE/PROTOCOL;../SOFTWARE/CONTROL;../SOFTWARE/SERVO;../SOFTWARE/IIC;../SOFTWARE/MPU6050;../SOFTWARE/DMP;../SOFTWARE/FILTER;../SOFTWARE/GIMBAL;../SOFTWARE/STMFLASH
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group SOFTWARE
    ../SOFTWARE/JSON/: cJSON.c
    ../SOFTWARE/PROTOCOL/: protocol.c
    ../SOFTWARE/CONTROL/: control.c
    ../SOFTWARE/SERVO/: servo.c
    ../SOFTWARE/IIC/: IOI2C.c
    ../SOFTWARE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../SOFTWARE/FILTER/: filter.c
    ../SOFTWARE/MPU6050/: mpu6050.c
    ../SOFTWARE/GIMBAL/: gimbal.c
    ../SOFTWARE/STMFLASH/: stmflash.c
software components: CMSIS:CORE 4.3.0
